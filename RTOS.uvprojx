# Keil uVision project RTOS.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\RTOS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c switch.c readme.txt tBitmap.c tConfig.h tList.c tTask.c tTime.c tCpu.c app.c tEvent.h tEvent.c tTask.h tSem.h tSem.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
