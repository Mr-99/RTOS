<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Target 1</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Listings\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>7</CpuCode>
      <DebugOpt>
        <uSim>1</uSim>
        <uTrg>0</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 )  -FN1 -FC1000 -FD20000000 -FF0NEW_DEVICE -FL080000 -FS00 -FP0($$Device:ARMCM4$Device\ARM\Flash\NEW_DEVICE.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGDARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)(1012=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name>-T0</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>PWSTATINFO</Key>
          <Name>200,50,700</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint/>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>taskTable[31]</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>highestPrio,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>currentTask</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>nextTask</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>tidleTask</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>node</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>tTask1</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>taskInfo,0x10</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>test,0x10</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>count</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>1</WinNumber>
          <ItemText>wakeUpCount</ItemText>
        </Ww>
        <Ww>
          <count>11</count>
          <WinNumber>1</WinNumber>
          <ItemText>node</ItemText>
        </Ww>
        <Ww>
          <count>12</count>
          <WinNumber>1</WinNumber>
          <ItemText>sem2</ItemText>
        </Ww>
        <Ww>
          <count>13</count>
          <WinNumber>1</WinNumber>
          <ItemText>sem1</ItemText>
        </Ww>
        <Ww>
          <count>14</count>
          <WinNumber>1</WinNumber>
          <ItemText>taskPrioBitmap</ItemText>
        </Ww>
        <Ww>
          <count>15</count>
          <WinNumber>1</WinNumber>
          <ItemText>semInfo</ItemText>
        </Ww>
        <Ww>
          <count>16</count>
          <WinNumber>1</WinNumber>
          <ItemText>mbox1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>17</count>
          <WinNumber>1</WinNumber>
          <ItemText>mbox1MsgBuffer</ItemText>
        </Ww>
        <Ww>
          <count>18</count>
          <WinNumber>1</WinNumber>
          <ItemText>msg,0x10</ItemText>
        </Ww>
        <Ww>
          <count>19</count>
          <WinNumber>1</WinNumber>
          <ItemText>mbox1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>20</count>
          <WinNumber>1</WinNumber>
          <ItemText>mbox2</ItemText>
        </Ww>
        <Ww>
          <count>21</count>
          <WinNumber>1</WinNumber>
          <ItemText>task_flag2</ItemText>
        </Ww>
        <Ww>
          <count>22</count>
          <WinNumber>1</WinNumber>
          <ItemText>mboxinfo,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>23</count>
          <WinNumber>1</WinNumber>
          <ItemText>memBlock1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>24</count>
          <WinNumber>1</WinNumber>
          <ItemText>block[0]</ItemText>
        </Ww>
        <Ww>
          <count>25</count>
          <WinNumber>1</WinNumber>
          <ItemText>block[1]</ItemText>
        </Ww>
        <Ww>
          <count>26</count>
          <WinNumber>1</WinNumber>
          <ItemText>tTask2</ItemText>
        </Ww>
        <Ww>
          <count>27</count>
          <WinNumber>1</WinNumber>
          <ItemText>task_flag2,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>28</count>
          <WinNumber>1</WinNumber>
          <ItemText>block[2]</ItemText>
        </Ww>
        <Ww>
          <count>29</count>
          <WinNumber>1</WinNumber>
          <ItemText>task_flag1,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>30</count>
          <WinNumber>1</WinNumber>
          <ItemText>info,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>31</count>
          <WinNumber>1</WinNumber>
          <ItemText>flagGroup1</ItemText>
        </Ww>
        <Ww>
          <count>32</count>
          <WinNumber>1</WinNumber>
          <ItemText>mutex,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>33</count>
          <WinNumber>1</WinNumber>
          <ItemText>mutex</ItemText>
        </Ww>
        <Ww>
          <count>34</count>
          <WinNumber>1</WinNumber>
          <ItemText>info,0x0A</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>nextTask</ItemText>
        </Ww>
      </WatchWindow2>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <LogicAnalyzers>
        <Wi>
          <IntNumber>0</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>1</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>2</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>3</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>4</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>5</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>6</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>7</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>8</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>9</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>10</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>11</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>12</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>13</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>14</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>15</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>16</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>17</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>18</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>19</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>20</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>21</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>22</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>23</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>24</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>25</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>26</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>27</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>28</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>29</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>30</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>31</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>32</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>33</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>34</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>35</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>36</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>37</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>38</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>39</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>40</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>41</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>42</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>43</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>44</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>45</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>46</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>47</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>48</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>49</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>50</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>51</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>52</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>53</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>54</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>55</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>56</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>57</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>58</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>59</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>60</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>61</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>62</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
        <Wi>
          <IntNumber>63</IntNumber>
          <FirstString>`task_flag2</FirstString>
          <SecondString>FF0000000000C0FFFFFFDFC10000C0FFFFFFDF41000000000000000000000000000000007461736B5F666C616732000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000000004100000001000000000000000000F03F170000000000000000000000000000000000000004030000</SecondString>
        </Wi>
      </LogicAnalyzers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Source Group 1</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\switch.c</PathWithFileName>
      <FilenameWithoutPath>switch.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\readme.txt</PathWithFileName>
      <FilenameWithoutPath>readme.txt</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tBitmap.c</PathWithFileName>
      <FilenameWithoutPath>tBitmap.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tConfig.h</PathWithFileName>
      <FilenameWithoutPath>tConfig.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tList.c</PathWithFileName>
      <FilenameWithoutPath>tList.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tTask.c</PathWithFileName>
      <FilenameWithoutPath>tTask.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tTime.c</PathWithFileName>
      <FilenameWithoutPath>tTime.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tCpu.c</PathWithFileName>
      <FilenameWithoutPath>tCpu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\app.c</PathWithFileName>
      <FilenameWithoutPath>app.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tEvent.h</PathWithFileName>
      <FilenameWithoutPath>tEvent.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tEvent.c</PathWithFileName>
      <FilenameWithoutPath>tEvent.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tTask.h</PathWithFileName>
      <FilenameWithoutPath>tTask.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tSem.h</PathWithFileName>
      <FilenameWithoutPath>tSem.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tSem.c</PathWithFileName>
      <FilenameWithoutPath>tSem.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>5</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tMbox.h</PathWithFileName>
      <FilenameWithoutPath>tMbox.h</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tMbox.c</PathWithFileName>
      <FilenameWithoutPath>tMbox.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tMenBlock.c</PathWithFileName>
      <FilenameWithoutPath>tMenBlock.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tFlagGroup.c</PathWithFileName>
      <FilenameWithoutPath>tFlagGroup.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\tMutex.c</PathWithFileName>
      <FilenameWithoutPath>tMutex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>drive</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
  </Group>

  <Group>
    <GroupName>::CMSIS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

  <Group>
    <GroupName>::Device</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>1</RteFlg>
  </Group>

</ProjectOpt>
